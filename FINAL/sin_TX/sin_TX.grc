<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>1430e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_bw</value></param>
<param><key>value</key><value>5e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>700e3</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>limesdr_sink</key>
<param><key>id</key><value>limesdr_sink_0</value></param>
<param><key>allow_tcxo_dac</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>5e6</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>55</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>pa_path_ch1</key><value>1</value></param>
<param><key>channel_mode</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>fc</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>dacVal</key><value>125</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1</value></param>
<param><key>bw</key><value>fft_bw</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"PSD aat Tx"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"B/Band Wave at Tx"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
